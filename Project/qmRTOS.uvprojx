# Keil uVision project qmRTOS.uvprojx, settings and files
target qmRTOS (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: qmRTOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Source
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group src
    ./Source/: main.c switch.c qBitmap.c qList.c qTask.c qTime.c qCpu.c app.c qEvent.c qSem.c qMbox.c qMemBlock.c
  group inc
    ./Source/: qmRTOS.h qLib.h qConfig.h qEvent.h qTask.h qSem.h qMbox.h qMemBlock.h
  group Debug
    ./Source/Debug/: Debug.c Debug.h
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.1
